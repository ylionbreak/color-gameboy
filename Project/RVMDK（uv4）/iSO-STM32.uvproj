# Keil uVision project iSO-STM32.uvproj, settings and files
target SPI（W25Q16） (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\key;..\..\User\spi;..\..\User\DY;..\..\User\led;..\..\User\SysTick;..\..\User\TimBase;..\..\User\shu;..\..\User\music
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group USER
    ../../User/: stm32f10x_conf.h stm32f10x_it.c main.c
    ../../User/spi/: bsp_spi_flash.c
    ../../User/TimBase/: bsp_TiMbase.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/led/: led.c
    ../../User/key/: key.c
    ../../User/DY/: DY.c
    ../../User/shu/: shu.c
    ../../User/music/: music.c
  group DOC
    ../../Doc/: readme.txt
